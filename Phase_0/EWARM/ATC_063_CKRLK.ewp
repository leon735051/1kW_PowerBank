# IAR project ATC_063_CKRLK.ewp, settings and files
configuration ATC_063_CKRLK (ARM, debug)
  General.OGChipSelectEditMenu: STM32L431RC ST STM32L431RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L431xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\Application
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ATC_063_CKRLK.hex
  ILINK.IlinkOutputFile: ATC_063_CKRLK.out
  ILINK.IlinkIcfFile: stm32l431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Application/User/driver_bsp
    ../Application/driver_bsp/: CANpal_bsp.c CANpal_bsp.h flash_bsp.c flash_bsp.h i2c_bsp.c i2c_bsp.h lpiTimer_bsp.c lpiTimer_bsp.h PortIRQ_bsp.c PortIRQ_bsp.h PortMux_bsp.c PortMux_bsp.h rtc_bsp.c rtc_bsp.h
  group Application/User/module_app/bms_mod
    ../Application/module_app/bms_mod/: bms_mod.c bms_mod.h err_mod.c err_mod.h
  group Application/User/module_app/bqMaximo
    ../Application/module_app/bqMaximo/: bqCommands.h bqDevConfig.h bqInterface.c bqMaximo.c bqMaximo.h
  group Application/User/module_app/CoulCount
    ../Application/module_app/CoulCount/: CoulCount.c CoulCount.h
  group Application/User/module_app/flash_mod
    ../Application/module_app/flash_mod/: flash_mod.c flash_mod.h
  group Application/User/module_app/protocol_stack
    ../Application/module_app/protocol_stack/: protocol_stack.c protocol_stack.h tp2101_stack.c tp2101_stack.h
  group Application/User/system_app
    ../Application/system_app/: mainThread.c mainThread.h sysLED_mod.c sysLED_mod.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_can.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
